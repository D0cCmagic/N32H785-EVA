# Keil uVision project LWIP_PING.uvprojx, settings and files
target N32H73x_76x (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32H760xIx7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x1E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: LWIP_PING +hex
  AfterMake: fromelf --bin --output=.\N32H73x_76x\bin\LWIP_PING.bin .\N32H73x_76x\Objects\LWIP_PING.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H73x_76x,CORE_CM7,USE_STDPERIPH_DRIVER,USING_TCM,__ICACHE_PRESENT=1,__DCACHE_PRESENT=1
  c include: ..\inc;..\bsp\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32h7xx_std_periph_driver\inc;..\lwip-2.2.0\src\include;..\lwip-2.2.0\src\include\compat;..\lwip-2.2.0\src\include\lwip;..\lwip-2.2.0\src\include\lwip\apps;..\lwip-2.2.0\src\include\lwip\priv;..\lwip-2.2.0\src\include\lwip\prot;..\lwip-2.2.0\src\include\netif;..\bsp;..\bsp\arch
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\M7_TCM.sct
  group USER
    ../src/: main.c n32h7xx_it.c
  group Mcal
    ../Mcal/src/: r900pnr_spi_init.c Mcal_LedGpio_Init.c Mcal_InitSum.c Mcal_TimerTask.c
  group Hardware
    ../Hardware/src/: App_R900PNR_Handle.c App_OTA_Handle.c App_VectorTable.c App_TaskServer_Handle.c
  group R900PNR_CMD
    ../R900PNR_CMD/: hgic_cmd.c hgic_raw.c hgic_sdspi_v2.c r900pnr_spi_api.c
  group STARTUP
    ../firmware/CMSIS/device/startup/: startup_n32h73x_76x.s startup_n32h78x_cm7.s
  group CMSIS
    ../firmware/CMSIS/device/: system_n32h7xx.c
  group FWLB
    ../firmware/n32h7xx_std_periph_driver/src/: misc.c n32h7xx_eth.c n32h7xx_exti.c n32h7xx_gpio.c n32h7xx_rcc.c n32h7xx_usart.c n32h7xx_pwr.c n32h7xx_spi.c n32h7xx_dcmu.c n32h7xx_dma.c n32h7xx_dmamux.c
  group BSP
    ../bsp/src/: log.c delay.c
  group DOC
    ../: readme.txt
target N32H78x (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: N32H785xIx7:CM7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x001E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: LWIP_PING +hex
  AfterMake: fromelf --bin --output=.\N32H78x\bin\LWIP_PING.bin .\N32H78x\Objects\LWIP_PING.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: N32H78x,CORE_CM7,USE_STDPERIPH_DRIVER,USING_TCM,__ICACHE_PRESENT=1,__DCACHE_PRESENT=1
  c include: ..\inc;..\bsp\inc;..\firmware\CMSIS\core;..\firmware\CMSIS\device;..\firmware\n32h7xx_std_periph_driver\inc;..\lwip-2.2.0\src\include;..\lwip-2.2.0\src\include\compat;..\lwip-2.2.0\src\include\lwip;..\lwip-2.2.0\src\include\lwip\apps;..\lwip-2.2.0\src\include\lwip\priv;..\lwip-2.2.0\src\include\lwip\prot;..\lwip-2.2.0\src\include\netif;..\bsp;..\bsp\arch;..\Hardware\src;..\Hardware\inc;..\Mcal\src;..\Mcal\inc;..\R900PNR_CMD;..\firmware\n32h7xx_std_periph_driver\inc;..\MDK-ARM
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\M7_TCM.sct
