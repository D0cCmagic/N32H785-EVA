# Keil uVision project Bootloader.uvprojx, settings and files
target N32H76x (6240000::V6.24::ARMCLANG)
  device: N32H785XIB7EC:CM7 Nationstech
  pack: Nationstech.N32H7xx_DFP.1.2.0
  cpu: IRAM(0x24000000,0x20000) IROM(0x15000000,0x001E0000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Bootloader +hex
  AfterMake: fromelf --bin --output=.\N32H76x\bin\Bootloader.bin .\N32H76x\Objects\Bootloader.axf
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: N32H76x,CORE_CM7,USE_STDPERIPH_DRIVER,N32H78x,USING_TCM
  c include: ..\inc;..\upgrade;..\..\firmware\n32h7xx_std_periph_driver\src;..\..\bsp\src;..\..\firmware\n32h7xx_std_periph_driver\inc;..\..\firmware\CMSIS\device;..\..\bsp\inc;..\..\firmware\CMSIS\device\startup;..\..\firmware\CMSIS\core
  library: MicroLIB
  memory RVCT4: ROM 0x15000000 size 0x1e0000
  memory RVCT9: RAM 0x24000000 size 0x20000
  scatter file: .\M7_Bootloader.sct
  group STARTUP
    ../../firmware/CMSIS/device/startup/: startup_n32h73x_76x.s
  group CMSIS
    ../src/: system_n32h7xx.c
  group FWLB
    ../../firmware/n32h7xx_std_periph_driver/src/: misc.c n32h7xx_crc.c n32h7xx_dma.c n32h7xx_dmamux.c n32h7xx_gpio.c n32h7xx_rcc.c n32h7xx_usart.c n32h7xx_smu.c
  group USER
    ../src/: main.c n32h7xx_it.c uart.c
  group BSP
    ../../bsp/src/: delay.c
  group UPGRADE
    ../upgrade/: crc.c IAP.c xmodem.c
  group DOC
    ../: readme.txt
